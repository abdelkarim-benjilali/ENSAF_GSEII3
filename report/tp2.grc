options:
  parameters:
    generate_options: qt_gui
    id: tp2
    output_language: python
    title: tp2
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: longueur.longueur()
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: F:\karim\s5\traitement de signal de parole\tp2\file2.wav
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
    vlen: longueur.longueur()
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: longueur.longueur()
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: longueur.longueur()
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: longueur.longueur()
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: F:\karim\s5\traitement de signal de parole\tp1\file.wav
    repeat: 'False'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: longueur.longueur()
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(1024)
  states: {}
- name: longueur
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\r\nfrom os.path import dirname, join as pjoin\r\nfrom scipy.io import wavfile\r\nimport scipy.io\r\ndef longueur():\r\n\t\r\n\tdata_dir = pjoin(dirname(scipy.io.__file__), 'F:', '/karim/s5/traitement de signal de parole/tp1')\r\n\twav_fname = pjoin(data_dir, 'file.wav')\r\n\r\n\tsamplerate, data = wavfile.read(wav_fname)\r\n\t#print(\"number of channels = {data.shape[1]}\")\r\n\t#print(data.shape)\r\n\tlength = data.shape[0] / samplerate\r\n\t#print(\"length\")\r\n\t#print(length)\r\n\t#print(samplerate)\r\n\t#length = 0.01s\r\n\treturn samplerate "
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
